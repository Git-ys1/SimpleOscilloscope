# Keil uVision project SimpleOscilloscope.uvprojx, settings and files
target Firmware (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SimpleOscilloscope +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,HSE_VALUE=8000000
  c include: .\user\inc;.\RTE\Device\STM32F103C8;D:\Work\Keil5\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\Include;D:\Work\Keil5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include
  asm include: .\RTE\Device\STM32F103C8;D:\Work\Keil5\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\Include;D:\Work\Keil5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./RTE/Device/STM32F103C8/: startup_stm32f10x_md.s system_stm32f10x.c
  group User
    ./user/src/: main.c board.c uart.c signal.c protocol.c
